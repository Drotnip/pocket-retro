/*
 * font5x7.h — tiny 5x7 pixel font for Pocket Retro.
 *
 * Each character is 5 bytes. Each byte is one vertical column of pixels.
 * Bit 0 of a byte is the TOP pixel of that column, bit 6 is the bottom.
 * Only the characters the game actually uses are included:
 * digits, capital letters, space, '.', ':', '-', '!'.
 */
#pragma once

#include <stdint.h>

static const uint8_t font5x7_digits[10][5] = {
    /* 0 */ {0x3E, 0x51, 0x49, 0x45, 0x3E},
    /* 1 */ {0x00, 0x42, 0x7F, 0x40, 0x00},
    /* 2 */ {0x42, 0x61, 0x51, 0x49, 0x46},
    /* 3 */ {0x21, 0x41, 0x45, 0x4B, 0x31},
    /* 4 */ {0x18, 0x14, 0x12, 0x7F, 0x10},
    /* 5 */ {0x27, 0x45, 0x45, 0x45, 0x39},
    /* 6 */ {0x3C, 0x4A, 0x49, 0x49, 0x30},
    /* 7 */ {0x01, 0x71, 0x09, 0x05, 0x03},
    /* 8 */ {0x36, 0x49, 0x49, 0x49, 0x36},
    /* 9 */ {0x06, 0x49, 0x49, 0x29, 0x1E},
};

static const uint8_t font5x7_letters[26][5] = {
    /* A */ {0x7E, 0x11, 0x11, 0x11, 0x7E},
    /* B */ {0x7F, 0x49, 0x49, 0x49, 0x36},
    /* C */ {0x3E, 0x41, 0x41, 0x41, 0x22},
    /* D */ {0x7F, 0x41, 0x41, 0x22, 0x1C},
    /* E */ {0x7F, 0x49, 0x49, 0x49, 0x41},
    /* F */ {0x7F, 0x09, 0x09, 0x09, 0x01},
    /* G */ {0x3E, 0x41, 0x49, 0x49, 0x7A},
    /* H */ {0x7F, 0x08, 0x08, 0x08, 0x7F},
    /* I */ {0x00, 0x41, 0x7F, 0x41, 0x00},
    /* J */ {0x20, 0x41, 0x41, 0x3F, 0x01},
    /* K */ {0x7F, 0x08, 0x14, 0x22, 0x41},
    /* L */ {0x7F, 0x40, 0x40, 0x40, 0x40},
    /* M */ {0x7F, 0x02, 0x0C, 0x02, 0x7F},
    /* N */ {0x7F, 0x04, 0x08, 0x10, 0x7F},
    /* O */ {0x3E, 0x41, 0x41, 0x41, 0x3E},
    /* P */ {0x7F, 0x09, 0x09, 0x09, 0x06},
    /* Q */ {0x3E, 0x41, 0x51, 0x21, 0x5E},
    /* R */ {0x7F, 0x09, 0x19, 0x29, 0x46},
    /* S */ {0x46, 0x49, 0x49, 0x49, 0x31},
    /* T */ {0x01, 0x01, 0x7F, 0x01, 0x01},
    /* U */ {0x3F, 0x40, 0x40, 0x40, 0x3F},
    /* V */ {0x1F, 0x20, 0x40,0x20, 0x1F},
    /* W */ {0x3F, 0x40, 0x38, 0x40, 0x3F},
    /* X */ {0x63, 0x14, 0x08, 0x14, 0x63},
    /* Y */ {0x07, 0x08, 0x70, 0x08, 0x07},
    /* Z */ {0x61, 0x51, 0x49, 0x45, 0x43},
};

/* Returns a pointer to the 5 column bytes for character c, or NULL
 * (meaning "draw nothing, just leave a blank space") for anything else. */
static inline const uint8_t *font5x7_get(char c)
{
    if (c >= '0' && c <= '9') {
        return font5x7_digits[c - '0'];
    }
    if (c >= 'A' && c <= 'Z') {
        return font5x7_letters[c - 'A'];
    }
    if (c >= 'a' && c <= 'z') {
        /* Lowercase letters are drawn as capitals. */
        return font5x7_letters[c - 'a'];
    }
    switch (c) {
    case '.': {
        static const uint8_t dot[5] = {0x00, 0x60, 0x60, 0x00, 0x00};
        return dot;
    }
    case ':': {
        static const uint8_t colon[5] = {0x00, 0x36, 0x36, 0x00, 0x00};
        return colon;
    }
    case '-': {
        static const uint8_t dash[5] = {0x08, 0x08, 0x08, 0x08, 0x08};
        return dash;
    }
    case '!': {
        static const uint8_t bang[5] = {0x00, 0x00, 0x5F, 0x00, 0x00};
        return bang;
    }
    case '+': {
        static const uint8_t plus[5] = {0x08, 0x08, 0x3E, 0x08, 0x08};
        return plus;
    }
    default:
        return NULL;
    }
}
